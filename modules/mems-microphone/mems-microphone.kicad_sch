File: modules/mems-microphone/mems-microphone.kicad_sch (KiCad schematic)
At the start: 6 parts

Commit message: Updating all modules
Other:
- moved on the sheet: C1, M1, R1, R2, R3
