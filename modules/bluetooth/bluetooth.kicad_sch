File: modules/bluetooth/bluetooth.kicad_sch (KiCad schematic)
At the start: 2 parts, among them U1 Microchip_BM83

Commit message: Updating all modules
Other:
- moved on the sheet: U1
