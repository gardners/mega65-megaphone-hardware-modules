File: modules/sim-and-sd-card/sim-and-sd-card.kicad_sch (KiCad schematic)
At the start: 2 parts

Commit message: Updating all modules
Other:
- moved on the sheet: J1, M1
